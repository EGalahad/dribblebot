Commit message: add cyberdog2 robot

File: resources/objects/ball.urdf (robot description, URDF)
Before this commit: robot ball, 1 links, 0 joints
Links:
- link ball: mass 0.318 -> 0.32; geometry collision sphere radius=0.125; visual sphere radius=0.125
